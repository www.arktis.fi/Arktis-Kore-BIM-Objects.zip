Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-12T11:30:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 12 11:30:41 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\f62316dd-7e75-44d8-8ea4-3234e9e4f772\e794d046-d57e-4204-94f7-483de131ddfb\ifc * Database version: 5507 * Database creation date: Thu Dec 12 11:30:40 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 12 11:30:40 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 12 11:30:40 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: KORE_S:KORE_S, KORE_S:KORE_S:353212
In: Level 1
Type - Material: Default Metal (4)
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Type - Pset_ProductRequirements - Category: Furniture
Pset_QuantityTakeOff - Reference: KORE_S
